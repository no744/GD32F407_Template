# Keil uVision project GD32F407.uvprojx, settings and files
target Target 1 (6210000::V6.21::ARMCLANG)
  device: GD32F407VE GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.0.3
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: GD32F407 +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: USE_STDPERIPH_DRIVER,GD32F407
  c include: ..\User;..\Firmware\CMSIS\GD\GD32F4xx\Include;..\Firmware\GD32F4xx_standard_peripheral\Include;..\Firmware\CMSIS;..\Hardware\usart;..\Hardware\I2C;..\Hardware\i2c_oled;..\third_party\u8g2;..\Hardware\SPI;..\Hardware\spi_oled;..\third_party\cst816;..\third_party\st7789;..\third_party\lv_drivers;..\third_party\lvgl;..\third_party
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../User/: gd32f4xx_it.c systick.c main.c app_config.h
  group CMSIS
    ../Firmware/CMSIS/GD/GD32F4xx/Source/ARM/: startup_gd32f407_427.s
    ../Firmware/CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
  group Firmware
    ../Firmware/GD32F4xx_standard_peripheral/Source/: gd32f4xx_gpio.c gd32f4xx_rcu.c gd32f4xx_misc.c gd32f4xx_usart.c gd32f4xx_i2c.c gd32f4xx_spi.c gd32f4xx_exti.c gd32f4xx_syscfg.c gd32f4xx_dma.c gd32f4xx_timer.c
  group Hardware
    ../Hardware/usart/: usart0.c
    ../Hardware/I2C/: I2C.c I2C0.c
    ../Hardware/i2c_oled/: i2c_oled.c
    ../Hardware/SPI/: SPI.c SPI0.c SPI2.c SPI4.c
    ../Hardware/spi_oled/: spi_oled.c
  group Doc
    ../Doc/: readme.txt
  group examples
    ../examples/: example_i2c_oled.c example_u8g2_oled.c example_usart.c example_spi_oled.c example_st7789.c example_lvgl.c
  group third_party
    ../third_party/u8g2/: mui.c mui_u8g2.c u8g2_arc.c u8g2_bitmap.c u8g2_box.c u8g2_buffer.c u8g2_button.c u8g2_circle.c u8g2_cleardisplay.c u8g2_d_memory.c u8g2_d_setup.c u8g2_font.c u8g2_fonts.c u8g2_hvline.c u8g2_input_value.c u8g2_intersection.c u8g2_kerning.c u8g2_line.c u8g2_ll_hvline.c u8g2_message.c u8g2_polygon.c u8g2_selection_list.c u8g2_setup.c u8log.c u8log_u8g2.c u8log_u8x8.c u8x8_8x8.c u8x8_byte.c u8x8_cad.c u8x8_capture.c u8x8_d_ssd1306_128x64_noname.c u8x8_debounce.c u8x8_display.c u8x8_fonts.c u8x8_gpio.c u8x8_input_value.c u8x8_message.c u8x8_selection_list.c u8x8_setup.c u8x8_string.c u8x8_u8toa.c u8x8_u16toa.c
  group third_party/cst816
    ../third_party/cst816/: cst816t.c
  group third_party/st7789
    ../third_party/st7789/: st7789.c
  group third_party/lvgl
    ../third_party/lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
    ../third_party/lvgl/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../third_party/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
    ../third_party/lvgl/src/extra/: lv_extra.c
    ../third_party/lvgl/src/extra/layouts/flex/: lv_flex.c
    ../third_party/lvgl/src/extra/layouts/grid/: lv_grid.c
    ../third_party/lvgl/src/extra/themes/basic/: lv_theme_basic.c
    ../third_party/lvgl/src/extra/widgets/animimg/: lv_animimg.c
    ../third_party/lvgl/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../third_party/lvgl/src/extra/widgets/chart/: lv_chart.c
    ../third_party/lvgl/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../third_party/lvgl/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../third_party/lvgl/src/extra/widgets/keyboard/: lv_keyboard.c
    ../third_party/lvgl/src/extra/widgets/led/: lv_led.c
    ../third_party/lvgl/src/extra/widgets/list/: lv_list.c
    ../third_party/lvgl/src/extra/widgets/menu/: lv_menu.c
    ../third_party/lvgl/src/extra/widgets/meter/: lv_meter.c
    ../third_party/lvgl/src/extra/widgets/msgbox/: lv_msgbox.c
    ../third_party/lvgl/src/extra/widgets/span/: lv_span.c
    ../third_party/lvgl/src/extra/widgets/spinbox/: lv_spinbox.c
    ../third_party/lvgl/src/extra/widgets/spinner/: lv_spinner.c
    ../third_party/lvgl/src/extra/widgets/tabview/: lv_tabview.c
    ../third_party/lvgl/src/extra/widgets/tileview/: lv_tileview.c
    ../third_party/lvgl/src/extra/widgets/win/: lv_win.c
    ../third_party/lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_14.c
    ../third_party/lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../third_party/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
    ../third_party/lvgl/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
  group third_party/lv_drivers
    ../third_party/lv_drivers/: lv_port_disp.c lv_port_indev.c
